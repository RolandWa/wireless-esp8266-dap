# Repository RolandWa/wireless-esp8266-dap

File README.md:

master　
 develop

[中文](README_CN.md)

## Project Link (QR)

Scan to open the project repository:

## Introduce

Wireless debugging with ***only one ESP Chip*** !

Realized by USBIP and CMSIS-DAP protocol stack.

> 👉 5m range, 100kb size firmware(Hex) earse and download test:

----

For Keil users, we now also support [elaphureLink](https://github.com/windowsair/elaphureLink). No need for usbip to start your wireless debugging!

## Feature

1. SoC Compatibility
    - [x] ESP8266/8285
    - [x] ESP32
    - [x] ESP32C3
    - [x] ESP32S3

2. Debug Communication Mode
    - [x] SWD
    - [x] JTAG

3. USB Communication Mode
    - [x] USB-HID
    - [x] WCID & WinUSB (Default)

4. Debug Trace (Uart)
    - [x] Uart TCP Bridge

5. More..
    - [x] SWD protocol based on SPI acceleration (Up to 40MHz)
    - [x] Support for [elaphureLink](https://github.com/windowsair/elaphureLink), fast Keil debug without drivers
    - [x] Support for [elaphure-dap.js](https://github.com/windowsair/elaphure-dap.js), online ARM Cortex-M firmware flash
    - [x] Support for [OpenOCD-elaphureLink](https://github.com/windowsair/openocd-elaphurelink), Get rid of USBIP!
    - [x] Support for OpenOCD/pyOCD
    - [x] ...

## Link your board

### WIFI

The default connected WIFI SSID is `DAP` or `OTA` , password `12345678`

Support for specifying multiple possible WAP. It can be added here: [wifi_configuration.h](main/wifi_configuration.h)

You can also specify your IP in the above file (We recommend using the static address binding feature of the router).

There is built-in ipv4 only mDNS server. You can access the device using `dap.local`.

> The mDNS in ESP8266 only supports ipv4.

#### Static IP assignment (ESP32-C3 / ESP32-S3)

When `USE_STATIC_IP 1` is set in [main/wifi_configuration.h](main/wifi_configuration.h), the
device does **not** use a fixed static IP directly. Instead it uses a two-phase approach:

1. **Connect via DHCP** — the WiFi stack gets any IP from the router so the network is reachable.
2. **Probe for a free address** — starting from the configured `DAP_IP_ADDRESS` (default
   `192.168.137.123`), the firmware sends an ICMP ping and waits 400 ms.
   - No reply → address is free → DHCP is stopped and that address is assigned statically.
   - Reply received → address is taken → last octet is incremented and the next candidate is probed.
   - This repeats up to `.255`; if no free address is found, DHCP is kept.

**Default configuration** (`wifi_configuration.h`):

```
DAP_IP_ADDRESS  192.168.137.123   ← starting candidate
DAP_IP_GATEWAY  192.168.137.1
DAP_IP_NETMASK  255.255.255.0
```

**Behaviour with multiple devices (same firmware binary):**

```
Device A boots  →  pings .123  →  free  →  takes 192.168.137.123
Device B boots  →  pings .123  →  taken →  pings .124  →  free  →  takes 192.168.137.124
Device C boots  →  pings .123  →  taken →  .124 taken  →  .125  →  takes 192.168.137.125
```

Each device claims the next free address in the range automatically — no configuration change needed
per device. The address a device gets depends on **boot order**, not on a fixed assignment.

> **Note:** If two devices reboot simultaneously they may both ping `.123` before either has
> claimed it, and both attempt to take the same address. For a lab with multiple devices where
> stable, predictable IPs are required across reboots, use the NVS provisioning approach
> described in the [TODO / Future Work](#todo--future-work) section.

#### AP fallback mode

If all configured SSIDs fail (after 5 attempts each), the device switches to **Access Point mode**
using the second entry in `wifi_list` (`DAP` / `12345678` by default). The AP IP is always
`192.168.4.1`. The LED stays on to indicate AP mode is active.

### Debugger

<details>
<summary>ESP8266</summary>

| SWD            |        |
|----------------|--------|
| SWCLK          | GPIO14 |
| SWDIO          | GPIO13 |
| TVCC           | 3V3    |
| GND            | GND    |

--------------

| JTAG               |         |
|--------------------|---------|
| TCK                | GPIO14  |
| TMS                | GPIO13  |
| TDI                | GPIO4   |
| TDO                | GPIO16  |
| nTRST \(optional\) | GPIO0\* |
| nRESET             | GPIO5   |
| TVCC               | 3V3     |
| GND                | GND     |

--------------

| Other              |               |
|--------------------|---------------|
| LED\_WIFI\_STATUS  | GPIO15        |
| Tx                 | GPIO2         |
| Rx                 | GPIO3 (U0RXD) |

> Rx and Tx is used for uart bridge, not enabled by default.

</details>

<details>
<summary>ESP32</summary>

| SWD            |        |
|----------------|--------|
| SWCLK          | GPIO14 |
| SWDIO          | GPIO13 |
| TVCC           | 3V3    |
| GND            | GND    |

--------------

| JTAG               |         |
|--------------------|---------|
| TCK                | GPIO14  |
| TMS                | GPIO13  |
| TDI                | GPIO18  |
| TDO                | GPIO19  |
| nTRST \(optional\) | GPIO25  |
| nRESET             | GPIO26  |
| TVCC               | 3V3     |
| GND                | GND     |

--------------

| Other              |               |
|--------------------|---------------|
| LED\_WIFI\_STATUS  | GPIO27        |
| Tx                 | GPIO23        |
| Rx                 | GPIO22        |

> Rx and Tx is used for uart bridge, not enabled by default.

</details>

<details>
<summary>ESP32C3</summary>

| SWD            |        |
|----------------|--------|
| SWCLK          | GPIO6  |
| SWDIO          | GPIO7  |
| TVCC           | 3V3    |
| GND            | GND    |

--------------

| JTAG               |         |
|--------------------|---------|
| TCK                | GPIO6   |
| TMS                | GPIO7   |
| TDI                | GPIO9   |
| TDO                | GPIO8   |
| nTRST \(optional\) | GPIO4   |
| nRESET             | GPIO5   |
| TVCC               | 3V3     |
| GND                | GND     |

--------------

| Other              |               |
|--------------------|---------------|
| LED\_WIFI\_STATUS      | GPIO10        |
| VTarget Sense          | GPIO2 (ADC0)  |
| VTarget Control (PWM)  | GPIO3         |
| Tx                     | GPIO21        |
| Rx                     | GPIO20        |

> Rx and Tx is used for uart bridge, not enabled by default.
>
> **Note for XIAO-ESP32-C3:** UART pins are GPIO21 (D6/TX) and GPIO20 (D7/RX).

#### VTarget Vendor Commands (ESP32-C3 / ESP32-S3 only)

VTarget sensing and control use CMSIS-DAP Vendor Commands via the pyOCD API.

> **pyOCD API note:** `probe.vendor(index, data)` takes an **index** (0–31), not the raw command ID.
> pyOCD computes `cmd_id = 0x80 + index` internally and strips the echoed byte from the response.

|Function|pyOCD call|Command ID|Request|Response|
|--------|----------|----------|-------|--------|
|Read VTarget|`probe.vendor(1, [])`|`0x81`|—|`[LOW, HIGH]` voltage in mV, little-endian. `0xFFFF` = error|
|Set VTarget|`probe.vendor(2, [LOW, HIGH])`|`0x82`|voltage in mV (1250–5000), little-endian|`[0x00]` success · `[0x01]` out of range · `[0xFF]` error|

**Python example:**

```python
# Read VTarget voltage (mV)
response = probe.vendor(1, [])          # index=1 → command 0x81
voltage_mv = response[0] | (response[1] << 8)
print(f"VTarget: {voltage_mv} mV ({voltage_mv/1000:.3f} V)")

# Set VTarget to 3.3V
mv = 3300
probe.vendor(2, [mv & 0xFF, (mv >> 8) & 0xFF])  # index=2 → command 0x82
```

**Measured accuracy (ESP32-C3 XIAO, eFuse Vref calibration, 20-sample average):**

|Supply (mV)|Measured (mV)|Error (mV)|Error (%)|
|-----------|-------------|----------|---------|
|606|614|+8|+1.3%|
|846|858|+12|+1.4%|
|1649|1662|+13|+0.8%|
|2604|2628|+24|+0.9%|
|2984|2994|+10|+0.3%|
|3460|3490|+30|+0.9%|
|3975|3997|+22|+0.6%|
|5054|5067|+13|+0.3%|

Max error: **+30 mV** at 3.46 V. Consistent positive offset bias (~10–30 mV) typical of ESP32-C3 ADC with 11 dB attenuation. All readings within ±1.5%.

</details>

<details>
<summary>ESP32S3</summary>

| SWD            |        |
|----------------|--------|
| SWCLK          | GPIO12 |
| SWDIO          | GPIO11 |
| TVCC           | 3V3    |
| GND            | GND    |

--------------

| JTAG               |        |
|--------------------|--------|
| TCK                | GPIO12 |
| TMS                | GPIO11 |
| TDI                | GPIO10 |
| TDO                | GPIO9  |
| nTRST \(optional\) | GPIO14 |
| nRESET             | GPIO13 |
| TVCC               | 3V3    |
| GND                | GND    |

</details>

----

## Hardware Reference

### ESP8266 Reference Design

Here we provide a simple example for reference:

### ESP32-C3 XIAO Reference Design

A complete hardware design for the Seeed Studio XIAO ESP32-C3 module is available with the following features:

- **Multiple Debug Connector Options:**
  - **J3:** 10-pin Cortex Debug (1.27mm pitch, SMD) - Compact SMD connector
  - **J1:** 10-pin Cortex Debug (2.54mm pitch, IDC) - Standard through-hole
  - **J2:** 20-pin ARM Standard JTAG (2.54mm pitch, IDC) - Compatible with J-Link and other standard debuggers
- **VTarget Voltage Sensing** via 1/2 voltage divider on GPIO2 (supports 0-6.6V range)
- **UART Bridge** on GPIO20 (RX/D7) and GPIO21 (TX/D6)
- **3.3V Target Power Supply** option with MOSFET switch
- Full schematic and PCB layout in KiCAD format

**Schematic:** [circuit_ESP32C3_Xiao/ESP32C3_Xiao_wireless_DAP.kicad_sch](circuit_ESP32C3_Xiao/ESP32C3_Xiao_wireless_DAP.kicad_sch)

**Schematic PDF:** [circuit_ESP32C3_Xiao/documentations/ESP32C3_Xiao_wireless_DAP.pdf](circuit_ESP32C3_Xiao/documentations/ESP32C3_Xiao_wireless_DAP.pdf)

**Schematic Diagram:**

**Additional Documentation:** [circuit_ESP32C3_Xiao/doc/](circuit_ESP32C3_Xiao/doc/) includes ARM JTAG connector pinouts and component datasheets

**PCBA Preview:**

**Key Features:**
- Seeed Studio XIAO ESP32-C3 module
- Three connector options for maximum compatibility:
  - 1.27mm pitch for space-constrained applications
  - 2.54mm pitch 10-pin for standard probe compatibility
  - 2.54mm pitch 20-pin for J-Link and ARM standard debuggers
- Target voltage monitoring via DAP Vendor Command (0x81)
- Bi-directional UART bridge for SWO/RTT trace capture
- Level shifter compatible design (3.3V target support)
- Compatible with OpenOCD, pyOCD, Keil, and other standard ARM debugging tools

**Programmable VTarget Implementation:**

For ESP32-C3 XIAO designs, a programmable target voltage feature (1.25V-5V) is available using PWM-controlled voltage regulation. See the detailed implementation guide: [VTARGET_PWM_IMPLEMENTATION.md](circuit_ESP32C3_Xiao/documentations/VTARGET_PWM_IMPLEMENTATION.md)

***Alternatively, you can connect directly with wires as we gave at the beginning, without additional circuits.***

Additional hardware reference designs are available from contributors in the [circuit](circuit) folder.

------

## Build And Flash

You can build locally (WSL) or use GitHub Actions to build online and download the firmware.

### Build with GitHub Actions (Online)

Push to the branch — CI runs automatically and uploads firmware as build artifacts.
See [.github/workflows/main.yml](.github/workflows/main.yml).

### Build Locally — WSL / Windows (Recommended)

> Full details, troubleshooting, and environment notes: **[docs/build_wsl.md](docs/build_wsl.md)**

**Requirements:** WSL2 Ubuntu, Python 3.10 (installed automatically), ESP-IDF **v4.4.2**.

```bash
# Run inside the Ubuntu WSL terminal — first-time setup + build:
python3 build_WSL.py

# Subsequent builds (setup already done):
python3 build_WSL.py --build

# Clean rebuild:
python3 build_WSL.py --build --clean
```

The script installs all dependencies, clones ESP-IDF v4.4.2, builds the firmware, and
merges everything into `~/build_wireless_dap/wireless_esp_dap_full.bin`.

**Flash to device (Windows, COM12):**

```bat
flash_eps.bat
```

> **Always use ESP-IDF v4.4.2 exactly.** This codebase targets v4.4 APIs.
> Building with IDF v5+ requires significant source changes and is not supported.

### Build for ESP8266

<details>
<summary>ESP8266</summary>

The SDK is already included. Do not use other SDK versions.

```bash
# Build
python ./idf.py build
# Flash
python ./idf.py -p /dev/ttyS5 flash
```

</details>

> Pre-built firmware for quick evaluation: [Releases](https://github.com/windowsair/wireless-esp8266-dap/releases)

## Usage

1. Get USBIP project

- Windows: [usbip-win](https://github.com/cezanne/usbip-win) .
- Linux: Distributed as part of the Linux kernel, but we have not yet tested on Linux platform, and the following instructions are all under Windows platform.

2. Start ESP chip and connect it to the device to be debugged

3. Connect it with usbip:

```bash
# HID Mode only
# for pre-compiled version on SourceForge
# or usbip old version
.\usbip.exe -D -a <your-esp-device-ip-address>  1-1

# 👉 Recommend
# HID Mode Or WinUSB Mode
# for usbip-win 0.3.0 kmdf ude
.\usbip.exe attach_ude -r <your-esp-device-ip-address> -b 1-1

```

If all goes well, you should see your device connected.

Here, we use MDK for testing:

------

## FAQ

### Keil is showing a "RDDI-DAP ERROR" or "SWD/JTAG Communication Failure" message.

1. Check your line connection. Don't forget the 3v3 connection cable.
2. Check that your network connection is stable.

### DAP is slow or often abnormal.

Note that this project is sensitive to the network environment. If you are using a hotspot on your computer, you can try using network analyzer such as wireshark to observe the status of your AP network. During the idle time, the network should stay silent, while in the working state, there should be no too much packet loss.

Some LAN broadcast packets can cause serious impact, including:
- DropBox LAN Sync
- Logitech Arx Control
- ...

For ESP8266, this is not far from UDP FLOOD...😰

It is also affected by the surrounding radio environment, your AP situation (some NICs have terrible AP performance), distance, etc.

----

## Document

### Speed Strategy

The maximum rate of esp8266 pure IO is about 2MHz.
When you select max clock, we will take the following actions:

- `clock < 2Mhz` : Similar to the clock speed you choose.
- `2MHz <= clock < 10MHz` : Use the fastest pure IO speed.
- `clock >= 10MHz` : SPI acceleration using 40MHz clock.

> Note that the most significant speed constraint of this project is still the TCP connection speed.

### For OpenOCD user

Connect directly over WiFi — **no USB cable, no USBIP kernel driver required**.

The recommended path is the elaphureLink OpenOCD (already installed at `c:\openocd\elaphurelink\`):

```bat
c:\openocd\elaphurelink\bin\openocd.exe ^
  -s c:\openocd\elaphurelink\share\openocd\scripts ^
  -f openocd/elaphurelink.cfg ^
  -f target/stm32f4x.cfg
```

Flash a `.bin` file to a target (example: Maxim MAX32672):

```bat
openocd\flash_max32672.bat firmware.bin
```

Or use OpenOCD commands directly:

```tcl
halt
flash write_image erase firmware.bin 0x10000000
verify_image firmware.bin 0x10000000
reset run
```

See **[docs/openocd.md](docs/openocd.md)** for all three connection paths (elaphureLink OpenOCD, Python bridge, pyOCD API) with full command examples.

### For pyOCD user

pyOCD 0.44+ can connect directly over WiFi via the elaphureLink TCP interface — **no USB driver or USBIP needed**:

```python
from tests.pyocd_elaphurelink import make_probe
from pyocd.core.session import Session

probe = make_probe("192.168.137.123")   # or "dap.local"
with Session(probe, target_override="your_target") as session:
    session.open()
    t = session.target
    t.halt()
    print(hex(t.read_core_register("pc")))
```

Standalone probe test (checks connection without a target MCU attached):

```bat
python tests/pyocd_elaphurelink.py --ip 192.168.137.123
```

### System OTA

When this project is updated, you can update the firmware over the air.

Visit the following website for OTA operations: [online OTA](http://corsacota.surge.sh/?address=dap.local:3241)

For most devices, you don't need to care about flash size. However, improper setting of the flash size may cause the OTA to fail. In this case, please change the flash size with `idf.py menuconfig`, or modify `sdkconfig`:

```
# Choose a flash size.
CONFIG_ESPTOOLPY_FLASHSIZE_1MB=y
CONFIG_ESPTOOLPY_FLASHSIZE_2MB=y
CONFIG_ESPTOOLPY_FLASHSIZE_4MB=y
CONFIG_ESPTOOLPY_FLASHSIZE_8MB=y
CONFIG_ESPTOOLPY_FLASHSIZE_16MB=y

# Then set a flash size
CONFIG_ESPTOOLPY_FLASHSIZE="2MB"
```

If flash size is 2MB, the sdkconfig file might look like this:

```
CONFIG_ESPTOOLPY_FLASHSIZE_2MB=y
CONFIG_ESPTOOLPY_FLASHSIZE="2MB"
```

For devices with 1MB flash size such as ESP8285, the following changes must be made:

```
CONFIG_PARTITION_TABLE_FILENAME="partitions_two_ota.1MB.csv"
CONFIG_ESPTOOLPY_FLASHSIZE_1MB=y
CONFIG_ESPTOOLPY_FLASHSIZE="1MB"
CONFIG_ESP8266_BOOT_COPY_APP=y
```

The flash size of the board can be checked with the esptool.py tool:

```bash
esptool.py -p (PORT) flash_id
```

### Uart TCP Bridge

Bridges **TCP port 1234 ↔ UART1** (GPIO21 TX / GPIO20 RX on ESP32-C3 XIAO).
Lets any PC application talk to a serial device wired to those pins — over WiFi,
no USB-serial adapter needed.

```text
PC TCP client (port 1234)
  ↕  WiFi
ESP32-C3
  ↕  GPIO21 TX / GPIO20 RX
Target MCU serial / AT modem / SWO trace
```

**Supported baud rates:** 9600 · 14400 · 19200 · 28800 · 38400 · 56000 · 57600 · 115200

**Enable** in [main/wifi_configuration.h](main/wifi_configuration.h):

```c
#define USE_UART_BRIDGE      1
#define UART_BRIDGE_PORT     1234
#define UART_BRIDGE_BAUDRATE 115200
```

**Connect** from Windows — pick any:

- **Python terminal:** `python tests/uart_bridge.py --baud 115200`
- **PuTTY:** see step-by-step below
- **Netcat:** `ncat dap.local 1234`

**Baud-rate negotiation:** the very first TCP packet, if it is a plain decimal number
(e.g. `"115200"`), reconfigures the UART to that rate before forwarding begins.
Each new baud rate requires a new TCP connection.

#### PuTTY — step by step

1. Open **PuTTY**.
2. Set **Connection type** → **Raw** (not SSH, not Telnet).
3. **Host Name:** `dap.local` (or `192.168.137.123`)
4. **Port:** `1234`
5. *(Optional)* Go to **Terminal → Local echo → Force on** so you can see what you type.
6. Click **Open**.
7. **Immediately type the baud rate** (e.g. `115200`) and press **Enter** — this is the
   baud-rate negotiation packet. Do this before sending any other data.
8. The UART is now running at that rate. Type commands / read responses normally.

> **Tip:** Save the session (Session → Saved Sessions → "DAP-UART") to avoid
> re-entering the host and port each time. The baud rate still needs to be sent
> manually after each connect.

**Loopback test** (GPIO20 shorted to GPIO21 — verifies all baud rates):

```bat
python tests/uart_bridge.py --loopback --all-bauds
```

Full details, use cases (SWO trace, AT commands, target console), and API reference:
**[docs/uart_bridge.md](docs/uart_bridge.md)**

### elaphure-dap.js

For the ESP8266, this feature is turned off by default. You can turn it on in menuconfig:

```
CONFIG_USE_WEBSOCKET_DAP=y
```

----

## TODO / Future Work

### Hardware — not yet assembled / tested

- [ ] **VTarget PWM circuit** — assemble AP1117-ADJ + MOSFET (Q1, R4, R5, R6, R7, C2, C3) on PCB;
  firmware (GPIO3 LEDC) is ready and confirmed sending commands correctly
- [ ] **VTarget calibration** — after hardware assembly, measure actual output with a multimeter at
  1.25 V, 1.8 V, 2.5 V, 3.3 V, 5.0 V and compare against requested voltage.
  If deviation > ~5%, replace the linear interpolation in `vtarget_set_voltage()` with a
  calibration lookup table (see `main/vtarget_pwm.c` and `docs/vtarget.md`)

### Testing — confirmed working in software, not yet exercised on real hardware

- [ ] **OpenOCD with a real SWD target** — `dap info` confirmed; run full debug session
  (e.g. STM32F4 or MAX32672) via `openocd/elaphurelink.cfg`
- [ ] **MAX32672 flash** — run `openocd/flash_max32672.bat` against real hardware
- [ ] **pyOCD with a real SWD target** — `make_probe()` handshake confirmed; test actual
  register read/write with a target connected to the SWD pins
- [ ] **UART bridge loopback at multiple baud rates** — 115200 confirmed; run
  `python tests/uart_bridge.py --loopback --all-bauds` with a loopback jumper on GPIO20/21
- [ ] **VTarget ADC accuracy** — cross-check 5216 mV reading against a calibrated meter

### Firmware — known issues from code review

- [ ] **`uart_bridge.c` — `uart_read_bytes` return type**: result (int, can be -1 on error)
  stored in `size_t uart_buf_len`; on error -1 becomes SIZE_MAX and is passed to
  `netconn_write` → buffer overread. Fix: use a separate `int n = uart_read_bytes(...);
  if (n > 0) netconn_write(..., (size_t)n, ...)`.
- [ ] **`uart_bridge.c` — `netconn_write` error ignored**: failed write (remote disconnect)
  leaves `is_conn_valid = true`; task loops retrying forever. Fix: check return value and
  clear `is_conn_valid` on `ERR_CLSD` / `ERR_RST`.
- [ ] **`uart_bridge.c` — double queue create**: `uart_bridge_init()` and `uart_bridge_task()`
  both call `xQueueCreate` for `uart_server_events`, leaking the first queue.
  Fix: remove the `xQueueCreate` call from `uart_bridge_init()`.
- [ ] **TCP keepalive** — no keepalive on the elaphureLink or USBIP sockets; a stale
  connection keeps the server blocked until a new client connects.

### Future features

- [ ] **xPack OpenOCD TCP bridge** (`openocd/cmsis_dap_tcp_bridge.py`) — packet framing
  for the xPack `cmsis-dap backend tcp` mode not yet matched; Path 3 is WIP
- [ ] **WebSocket DAP** — firmware advertises the WebSocket protocol variant; no client
  or test exists yet
- [ ] **SWO / trace capture** — firmware advertises SWO Manchester; no capture client tested

----

## Develop

Check other branches to know the latest development progress.

Any kind of contribute is welcome, including but not limited to new features, ideas about circuits, documentation.

You can also ask questions to make this project better.

- [New issues](https://github.com/windowsair/wireless-esp8266-dap/issues)
- [New pull](https://github.com/windowsair/wireless-esp8266-dap/pulls)

### Issue

2020.12.1

TCP transmission speed needs to be further improved.

2020.11.11

Winusb is now available, but it is very slow.

2020.2.4

Due to the limitation of USB-HID (I'm not sure if this is a problem with USBIP or Windows), now each URB packet can only reach 255 bytes (About 1MBps bandwidth), which has not reached the upper limit of ESP8266 transmission bandwidth.

I now have an idea to construct a Man-in-the-middle between the two to forward traffic, thereby increasing the bandwidth of each transmission.

2020.1.31

At present, the adaptation to WCID, WinUSB, etc. has all been completed. However, when transmitting data on the endpoint, we received an error message from USBIP. This is most likely a problem with the USBIP project itself.

Due to the completeness of the USBIP protocol document, we have not yet understood its role in the Bulk transmission process, which may also lead to errors in subsequent processes.

We will continue to try to make it work on USB HID. Once the USBIP problem is solved, we will immediately transfer it to work on WinUSB

------

## Credit

Credits to the following project, people and organizations:

> - https://github.com/thevoidnn/esp8266-wifi-cmsis-dap for adapter firmware based on CMSIS-DAP v1.0
> - https://github.com/ARM-software/CMSIS_5 for CMSIS
> - https://github.com/cezanne/usbip-win for usbip windows

- [@HeavenSpree](https://www.github.com/HeavenSpree)
- [@Zy19930907](https://www.github.com/Zy19930907)
- [@caiguang1997](https://www.github.com/caiguang1997)
- [@ZhuYanzhen1](https://www.github.com/ZhuYanzhen1)

## License

[MIT LICENSE](LICENSE)

## References
- Project upstream (windowsair/wireless-esp8266-dap): https://github.com/windowsair/wireless-esp8266-dap
- CMSIS (ARM): https://github.com/ARM-software/CMSIS_5
- ESP-IDF documentation: https://docs.espressif.com/projects/esp-idf/en/latest/
- usbip-win (Windows USBIP client): https://github.com/cezanne/usbip-win

## KiCad design circuit_ESP32C3_Xiao/ESP32C3_Xiao_wireless_DAP.kicad_pcb

Parts:
C1, C5: 10nF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; LCSC C9900224280
C2: 10uF /25V; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; LCSC C9900224280
C3, C4, C6: 10uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder; LCSC C9900006346
D1, D3: LED Red; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder; LCSC C9900007580
D2: LED green; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder; LCSC C9900002573
D4: 1N4148W; D_SOD-123; LCSC C2099
H1, H2, H3, H4: MountingHole; MountingHole_2.2mm_M2_Pad_Via
J1: Cortex Debug 10pin connector; IDC-Header_2x05_P2.54mm_Vertical; LCSC C9900010269
J2: ARM Standard JTAG; IDC-Header_2x10_P2.54mm_Horizontal; LCSC C109409
J3: Cortex Debug 10pin connector; PinHeader_2x05_P1.27mm_Vertical_SMD; LCSC C448647
J4: Conn_01x02; PinHeader_1x02_P2.54mm_Vertical; LCSC C124375
J6: Serial; PinSocket_1x03_P2.54mm_Vertical; LCSC C180248
Q1: YJL2304A; SOT-23; LCSC C699298
R1: 1.2k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; LCSC C114659
R2, R8, R9, R10, R11, R12, R13, R14: 120R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; LCSC C114640
R3: 2.7k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; LCSC C114614
R4: 22k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; LCSC C163424
R5: 43k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; LCSC C98220
R6, R7: 100k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; LCSC C22356636
R15: 39; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; LCSC C2907032
R16, R17: 12k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; LCSC C114659
R18: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; LCSC C9900170064
R19: 220k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; LCSC C9900083237
U1: XIAO-ESP32-C3-SMD; MCU_Seeed_ESP32C3; LCSC C9900071238
U2: AP1117-ADJ; SOT-223-3_TabPin2; LCSC C6190
V1: VPULSE
V2: 5
V3: VPWL

Connections:
+3V3: C6.1, U1.12 (3V3)
+5V: C4.1, R19.2, U1.14 (5V), U2.3 (VI), V2.1
/INPut: C2.1, D4.1 (K), Q1.1 (G), R5.2, R19.1
/TCK/SWDCLK: J1.4, J2.9, J3.4, R12.1
/TDI: J1.8, J2.5, J3.8, R2.2
/TDO/SWO: J1.6, J2.13, J3.6, R8.2
/TMS/SWDIO: J1.2, J2.7, J3.2, R13.1
/VCOM_RX: J1.7, J2.17, J3.7, J6.3, R9.2
/VCOM_TX: J1.5, J2.11, J3.5, J6.1, R14.1
/VTarget: C3.1, D1.2 (A), J1.9, J2.19, J3.9, R1.1, U2.2 (VO)
/VTarget_PWM: R4.1, U1.2 (GPIO3_A1_D1), V1.1
/VTref: D2.2 (A), J1.1, J2.1, J2.2, J3.1, J4.1, R6.2
/VTref_div: C5.1, R6.1, R7.2, U1.1 (GPIO2_A0_D0)
/Vadj: C1.1, R1.2, R3.1, R15.1, U2.1 (ADJ)
/nRST: J1.10, J2.15, J3.10, R11.1
/nTRST: J2.3, R10.1
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, J1.3, J2.4, J2.6, J2.8, J2.10, J2.12, J2.14, J2.16, J2.18, J2.20, J3.3, J6.2, Q1.2 (S), R3.2, R5.1, R7.1, R16.2, R17.2, R18.2, U1.13 (GND), U1.16 (GND), U1.20 (GND), V1.2, V2.2
unnamed: D1.1 (K), R16.1
unnamed: D2.1 (K), R17.1
unnamed: D3.2 (A), U1.11 (GPIO10_D10_MOSI)
unnamed: D3.1 (K), R18.1
unnamed: D4.2 (A), R4.2
unnamed: J4.2, U1.15 (BAT)
unnamed: Q1.3 (D), R15.2
unnamed: R10.2, U1.3 (GPIO4_A2_D2)
unnamed: R11.2, U1.4 (GPIO5_A3_D3)
unnamed: R12.2, U1.5 (GPIO6_D4_SDA)
unnamed: R13.2, U1.6 (GPIO7_D5_SCL)
unnamed: R8.1, U1.9 (GPIO8_D8_SCK)
unnamed: R2.1, U1.10 (GPIO9_D9_MISO)
unnamed: R9.1, U1.8 (GPIO20_D7_RX)
unnamed: R14.2, U1.7 (GPIO21_D6_TX)

Notes on the sheet:
https://kb.segger.com/Debug_Connectors
Processor only for the 3V3 or lower , not 5V tolerant !!!
CONFIG_IDF_TARGET_ESP32C3 #define PIN_SWDIO _ // SPI MISO #define PIN_SWDIO_MOSI 7 // SPI MOSI #define PIN_SWCLK 6 #define PIN_TDO 8 // device TDO -> Host Data Input #define PIN_TDI 9 #define PIN_nTRST 4 // optional #define PIN_nRESET 5
AO3400A
.param pulse_width = 0.1 .param period = 20u ; .dc pulse_width 0.1 0.9 0.1 .OPTIONS METHOD=GEAR .OPTIONS RELTOL=0.01 .OPTIONS VNTOL=10uV
Connect if supply by the Target device
FTSH-105-01-L-DV-KSAMTEC Złącze: kołkowe; gniazdo; męskie; PIN: 10; pionowa; SMT; 1,27mm; 2x5

Board: 2 copper layers, 70.0 x 35.0 mm, 41 parts (0 on the bottom side), 32 nets.

## KiCad design circuit_ESP32C3_Xiao/Seeed Studio XIAO ESP32S3/ESP32S3.kicad_pcb

Board: 2 copper layers, 17.8 x 21.1 mm, 72 parts (11 on the bottom side), 62 nets.

Parts:
ANT1: U.FL-R-SMT-1; U-FL3P-SMD-2.6X2.6X1.0MM
BAT0: VBAT; TP-80X40MIL
C1, C2, C17, C20: DNP; C0201
C3, C9, C13, C16: 2.2uF; C0201
C4, C5, C6: 4.7uF; C0201
C7, C8, C28: 10pF; C0201
C10, C21, C25, C26: 1uF; C0201
C11, C14, C15, C19, C22, C23, C29, C30: 100nF; C0201
C12: 10nF; C0201
C18: 1pF; C0201
CHG0: RED; LED-0402
D2: LMBR4010BST5G; DFN1006-2L
D3: Yellow; LED-0402
GND0: GND; TP-80X40MIL
J1, J2: DNP; H7-HALF-HOLE-2.54
J3: DF40C-30DP-0.4V(51); BTB30-0.4-7.52X2.97X1.14
K1, K2: SKTAAAE010/311021459; SW4-SMD-2.8-2.6X1.6X0.53MM
L1: 2nH; L0201
L2: 3.3nH; L0201
L3: DNP; L0201
L4: 470nH; L0603
Q1: LP0404N3T5G; PMOS_1.0_0.6_0.35MM
R1, R2: 5.1K; R0201
R3, R4: 22R; R0201
R5: 0R; R0201
R6: 499R; R0201
R7, R8, R11: 10K; R0201
R9: 100K; C0201
R10: 220K; R0201
R13: 249K; R0201
R15: 1.5K; R0201
TP1, TP2, TP3, TP4, TP5, TP6, TP7, TP8: TP-D45MIL
U1: ESP32-S3R8; QFN56G-0.4-7X7MM
U3: SGM6029CYG/TR; BGA6-0.35-0.745X10.95X0.4MM
U4: SGM40567-4.2XG/TR; WLCSP-0.4-0.92X1.16X0.4MM
U5: GD25Q64ENIGR; USON8-0.8-4X3MM
U$7: LOGO-SEEED-NEW-0.94X8.4MM
USB0: UBF31-0171; USB2.0-TYPE-C
X1: 40MHz/306011364; X4-SMD-1.6X1.2X0.35MM

Connections:
D0/A0: J2.1, J2.13, U1.6
D1/A1: J2.2, J2.14, U1.7
D2/A2: J2.3, J2.15, J3.2, U1.8
D3/A3: J2.4, J2.16, U1.9
D4/I2C_SDA: J2.5, J2.17, U1.10
D5/I2C_SCL: J2.6, J2.18, U1.11
D6/TX: J2.7, J2.19, R6.2
D7/RX: J1.1, J1.13, U1.50
D8/A8/SCK: J1.2, J1.14, J3.3, U1.12
D9/A9/MISO: J1.3, J1.15, J3.4, U1.13
D10/A10/MOSI: J1.4, J1.16, J3.5, U1.14
EN: C21.2, K1.1, K1.3, R8.1, TP6.T, U1.4
ESP_USB_D+: C1.2, R4.2, TP8.T, U1.26
ESP_USB_D-: C2.2, R3.2, TP7.T, U1.25
GND: ANT1.GND1, ANT1.GND2, C1.1, C2.1, C3.2, C4.2, C5.1, C6.1, C7.2, C8.1, C9.1, C10.2, C11.1, C12.1, C13.1, C14.1, C15.1, C16.1, C17.1, C18.1, C19.1, C20.1, C21.1, C22.1, C23.2, C25.2, C26.2, C28.1, C29.1, C30.1, GND0.1, J1.6, J1.18, J3.1, J3.17, J3.28, J3.29, J3.31, J3.33, J3.34, K1.2, K1.4, K2.2, K2.4, R1.1, R2.2, R9.1, R10.1, R13.1, TP1.T, U1.57, U3.A1, U4.B1, U4.C2, U5.4, USB0.A1_B12, USB0.B1_A12, USB0.S1, USB0.S2, USB0.S3, USB0.S4, USB0.S5, USB0.S6, X1.2, X1.4
GND5: L4.1, U3.B2
GND6: R13.2, U3.C1
GPIO0: C28.2, K2.1, K2.3, R7.1, U1.5
IO10/XMCLK: J3.6, U1.15
IO11/DVP_Y8: J3.7, U1.16
IO12/DVP_Y7: J3.8, U1.17
IO13/DVP_PCLK: J3.9, U1.18
IO14/DVP_Y6: J3.10, U1.19
IO15/DVP_Y2: J3.11, U1.21
IO16/DVP_Y5: J3.12, U1.22
IO17/DVP_Y3: J3.13, U1.23
IO18/DVP_Y4: J3.14, U1.24
IO21/USER_LED: D3.-, J3.16, U1.27
IO38/DVP_VSYNC: J3.23, U1.43
IO47/DVP_HREF: J3.22, U1.37
IO48/DVP_Y9: J3.21, U1.36
MTCK/IO39/CAM_SCL: J3.24, TP5.T, U1.44
MTDI/IO41/PDM_DATA: J3.26, TP3.T, U1.47
MTDO/IO40/CAM_SDA: J3.25, TP4.T, U1.45
MTMS/IO42/PDM_CLK: J3.27, TP2.T, U1.48
unnamed: R5.1, U1.54
unnamed: C7.1, R5.2, X1.3
unnamed: C8.2, U1.53, X1.1
unnamed: ANT1.D, C17.2, L2.1, L3.2
unnamed: R2.1, USB0.B5
unnamed: C15.2, L1.2, U1.2, U1.3
unnamed: R1.2, USB0.A5
unnamed: C18.2, L2.2, U1.1
unnamed: CHG0.-, U4.B2
unnamed: R6.1, U1.49
unnamed: R10.2, U4.C1
unnamed: CHG0.+, R11.2
unnamed: D3.+, R15.1
unnamed: C20.2, L3.1
SPICLK: U1.33, U5.6
SPICS0: U1.32, U5.1
SPID: U1.35, U5.5
SPIHD: U1.30, U5.7
SPIQ: U1.34, U5.2
SPIWP: U1.31, U5.3
USB_D+: R4.1, USB0.A6, USB0.B6
USB_D-: R3.1, USB0.A7, USB0.B7
VBAT: BAT0.1, C26.1, Q1.1, U4.A1
VBUS: C10.1, C25.1, D2.+, J1.7, J1.19, Q1.2, R9.2, R11.1, U4.A2, USB0.A4_B9, USB0.B4_A9
VCC_3V3: C5.2, C6.2, C9.2, C11.2, C12.2, C13.2, C14.2, C16.2, C19.2, C23.1, C29.2, J1.5, J1.17, J3.18, J3.19, L1.1, L4.2, R7.2, R8.2, R15.2, U1.20, U1.46, U1.55, U1.56, U3.A2
VDD_SPI: C22.2, U1.29, U5.8
VIN: C3.1, C4.1, C30.2, D2.-, J3.15, J3.30, Q1.3, U3.B1, U3.C2

## Commit log (part)

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2020-12-26 feat: Add github action (#9)
2020-12-26 feat: Add github action (#9) (#10)
2021-02-25 feat: Try to support SWO (Still Unavailable)
2021-03-09 feat: Add static IP feature
2021-03-13 fix(ci): Fix invalid git tag name
2021-04-06 feat: Update SDK to v3.3
2021-04-06 fix(ci): Fix the ci problem of the sdk v3.3
2021-05-12 feat: Add support for USB 3.0
2021-05-31 fix(dap): JTAG speed
2021-06-05 chore: Refactor build dependencies
2021-06-07 docs: Update schematic
2021-10-02 fix(dap): Fix timing problems in the SPI
2021-10-03 fix(usbip): Try to handle UNLINK behavior
2021-10-09 feat(usbip): Add kcp support
2021-11-03 chore: test
2021-11-12 feat(lwip): Add netconn style tcp server
2021-12-21 Feature/circuit (#26)
    * feat: Add empty circuit project
    * add ESP8285 library to circuit
    * Add crystal to circuit
    * Finished circuit design
    * finished PCB design
2021-12-21 docs: Add new hardware reference description
2022-01-16 feat(mDNS): Add mDNS server
2022-01-17 feat(ota): Add ota support
2022-01-17 feat(ci): Release firmware as artifact
2022-01-18 Translate README.md to README_CN.md (#27)
    * Add README_CN.md, and translate README to Chinese.
    * Add Chinese document link
2022-01-18 feat: Try to connect to wap in the wifi list
2022-01-18 feat: Change LED behavior
2022-01-18 fix(wifi & uart): - wifi failed to connect - uart baud change
2022-01-20 fix: Eliminating unused gpio function warnings
2022-01-20 docs: Bump to v0.1.4
2022-02-25 Update circuit, fix issue #29 (#30)
    * Update circuit, Fix issue #29
    * Update README_CN, Translate from README.
2022-03-01 feat(ci): Ignore files
2022-03-01 docs: FAQ update
2022-07-22 feat: Add elaphureLink support
2022-09-05 feat(esp32): Add support for esp32
2022-09-10 feat(esp32): Update esp-idf to v4.4
2022-09-17 ci: Add support for esp32c3
2022-09-17 Revert "thirdparty: Update corsacOTA"
    This reverts commit fe0d2210f49ef0f0a01c1ed1948084d1f2219741.
2022-09-28 feat & ci: Update esp32c3 sdkconfig
2022-11-20 feat(dap): Add basic hardware reset based on nRESET
2023-04-15 ci: Update to ubuntu20.04
2023-11-05 ci: bump esptool to v4.6.2
2024-01-28 ci: update codeql to v3
    Use esp32 target to build code for codeql.
2024-01-28 feat(usb): change usb interface name to "Wireless ESP CMSIS-DAP"
    pyOCD identifies the debugger by USB interface name, which include
    substring "CMSIS-DAP". Let's change USB interface name to adapt pyOCD.
2024-02-16 refactor(network): Refactor usbip and tcp process code
    In previous versions, parsing of the usbip protocol was implemented
    via a global state machine and shared with elaphureLink.
    The refactored code removes these global state machines and handles them
    with the corresponding protocol header commands.
2024-04-21 feat(esp32s3) add support for esp32s3 (#72)
    * feat(esp32s3) add support for esp32s3
    * reformat coding style
    * fix(spi_switch) esp32s3: remove IOMUX SPI pin definition from DAP_config and hardcode it
    * fix(workflows) remove 'uses' while already having run
    * reformat spaces and remove unsed include
2024-04-21 fix(lib): Fix esp8266 SDK pyelftool broken in python 2
2024-04-28 feat(ota): Sync to support esp32s3 ota
2024-05-07 fix software reset by writing in SYSRESETQ register when a reset is requested (#73)
    Some debugger software (e.g. Keil) does not perform a software reset when
    resetting the target. When this option enabled, a soft reset is attempted
    when DAP_ResetTarget() is performed. This is done by writing to the
    SYSRESETREQ field of the AIRCR register in the Cortex-M architecture.
    This should work for ARMv6-m, ARMv7-m and ARMv8-m architecture. However,
    there is no guarantee that the reset operation will be executed correctly.
2024-06-09 feat(websocket): Add support for websocket transport layer
    This patch adds support for websocket servers, the websocket code is
    copied from corsacOTA.
2024-06-09 fix(dap): Only setup SWD port when using SPI speed
    Connection problems may occur at SPI speeds when DAP_Connect and
    DAP_SWJ_Clock are called in different orders.
    Let's setup SWD at SPI rates to avoid potential timing issues.
2024-06-09 feat(dap): Add websocket dap implementation
2024-06-09 feat(project): Add websocket dap default config
2024-10-18 ci: Bump upload-artifact to v4
2024-12-24 fix(dap): Fix not working at low speed
2024-12-24 feat(dap): Remove DAP_SPI_Enable()/DAP_SPI_Disable()
    These functions are no longer useful and can be misleading.
    Just remove them.
2025-02-25 feat(dap): Set pad drive strength for esp32s3/esp32c3
    The drive strength has a significant impact on signal integrity. In
    actual use, it is necessary to perform signal measurements on the
    board and select the appropriate drive strength.
2025-02-26 fix(esp8266): Fix IRAM out of memory
2025-03-02 feat(dap): Add dedicated gpio support for esp32c3
2025-03-02 feat(dap): Port swd host
2025-05-15 feat(dap): Add support for elaphureLink vendor command
2025-05-15 Update ESP8266_RTOS_SDK origin url
2025-05-15 docs: Add support for openOCD-elaphureLink
2025-07-14 fix(esp8266): correct UART port assignment for serial initialization
    ESP8266 only supports UART1 as TX-only. Previously, the code attempted to use UART1 as RX and UART0 as TX, causing initialization failure. This commit swaps the UART ports, assigning UART1 as TX and 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
2025-11-23 fix(wifi): Fix static IP handle
2025-11-28 Update main.yml
    Add ability to run manually
2025-11-28 Update codeql-analysis.yml
    Add manually run the script
2025-11-28 Update main.yml
    Add the git clone for the espressif.git and the sudo before the merge the binary files
2025-11-28 Update main.yml
    install sudo pip3 install ./esptool/
2025-11-28 Update main.yml
    remove the install esptool by the pip
2025-11-28 Update main.yml
    Force Enable MDNS in sdkconfig
2025-11-28 Update main.yml
    come back to first version
2025-11-28 Update main.yml
    Come back to beginning
2025-12-24 Create the ESP32C3_Xiao_wireless_DAP circuit using the XIAO module
2025-12-28 Update the circuit, and create proper SPICE simulation model.
2025-12-28 feat(ESP32C3): Add VTarget sensing and fix configuration for XIAO-ESP32-C3
    ## Major Features Added:
    - Implement VTarget voltage sensing on GPIO2 (ADC0) with 1/2 voltage divider
    * DAP Vendor Command 0x81 returns target voltage in millivolts
    * 20-sample averaging for stable measurements
    * Supports 0-6.6V target voltage range
    ## Bug Fixes:
2025-12-29 docs(README): Add reference to programmable VTarget implementation
    - Link to VTARGET_PWM_IMPLEMENTATION.md in ESP32-C3 XIAO section
    - Provide context for 1.25V-5V programmable voltage feature
2025-12-29 test: Add comprehensive hardware test suite for XIAO ESP32-C3
    Add Python test scripts for USB and WiFi interfaces:
    USB Interface Tests (test_xiao_usb.py):
    - USB device detection and DAP info retrieval
    - VTarget voltage reading (ADC on GPIO2)
    - VTarget voltage control (PWM on GPIO3, 1.25V-5.0V)
    - Voltage setpoint verification with <5% tolerance
2025-12-29 ci: Optimize build workflow - consolidate esptool, fix deprecated syntax, add size reporting
2025-12-29 Fix ESP8266 build: Add missing headers for bool and calloc
    ESP8266 build was failing with:
    - error: unknown type name 'bool'
    - error: 'false' undeclared
    - warning: incompatible implicit declaration of built-in function 'calloc'
    Solution: Add #include <stdbool.h> and #include <stdlib.h> to provide
    bool type and calloc function for all platforms.
2025-12-29 Improve VTarget vendor commands: Add memory cleanup, error handling, and logging
    Enhancements:
    1. Memory Management:
    - Add vtarget_adc_deinit() to properly free ADC calibration memory
    - Add null check after calloc() to prevent crashes on allocation failure
    2. Error Indication:
    - Return 0xFFFF (65535) on ADC read errors instead of 0V
2025-12-29 fix: Exclude vtarget_pwm from ESP8266 builds
    - Only compile vtarget_pwm.c for ESP32/ESP32-C3/ESP32-S3 targets
    - Fix format string compatibility (%u instead of %lu for uint32_t)
    - Resolves ESP8266 build errors with LEDC_AUTO_CLK and ledc_get_duty
2025-12-29 feat: Add full ESP32-S3 support and improve platform compatibility
    UART Bridge:
    - Add ESP32-S3 pin configuration (GPIO17/18)
    - All platforms now supported: ESP8266, ESP32, ESP32-C3, ESP32-S3
    VTarget PWM:
    - Fix LEDC clock compatibility for ESP-IDF < 4.4.0
    - Use LEDC_USE_APB_CLK as fallback for older SDK versions
2025-12-29 feat: Add ESP32-S3 XIAO board support and enable VTarget control for all ESP32 variants
    - Update UART bridge pins for XIAO-ESP32-S3 (GPIO43/44)
    - Enable VTarget PWM control for ESP32, ESP32-C3, and ESP32-S3
    - Vendor commands 0x81/0x82 now work on all ESP32 variants
2025-12-29 Fix ESP8266 build: remove driver component requirement
    ESP8266 build was failing with "Failed to resolve component 'driver'".
    Original code had no COMPONENT_REQUIRES for ESP8266.
    Only ESP32/C3/S3 need explicit esp_adc_cal+driver requirements.
    ESP8266 works without any COMPONENT_REQUIRES declaration.
2025-12-29 Fix ESP32 linker errors: add missing UART.c and vtarget weak stub
    - Add UART.c to DAP component COMPONENT_SRCS (was missing, causing undefined UART_* functions)
    - Provide weak stub for vtarget_set_voltage on platforms without VTarget support (ESP8266)
    - ESP32/C3/S3 will override the weak stub with actual implementation from main/vtarget_pwm.c
    Fixes linker errors:
    - undefined reference to UART_Transport, UART_Configure, UART_Control, UART_Status, UART_Transfer
    - undefined reference to vtarget_set_voltage
2025-12-29 Fix ESP8266 build: move all ADC functions inside ESP32 platform guard
    All ADC-related functions (vtarget_adc_deinit, vtarget_adc_init, vtarget_read_mv)
    and variables (adc_chars, adc_initialized, TAG) now inside ESP32/C3/S3 conditional block.
    ESP8266 gets only the weak stub for vtarget_set_voltage that returns ESP_ERR_NOT_SUPPORTED.
    Platform configuration verified:
    - UART: All platforms (ESP8266, ESP32, ESP32-C3, ESP32-S3)
    - ADC: ESP32/C3/S3 only (VTarget voltage sensing)
2025-12-29 Disable DAP UART for all ESP platforms - ARM CMSIS drivers not available
    UART.c requires ARM CMSIS drivers (Driver_USART.h, ARM_DRIVER_USART, cmsis_os2.h)
    which are only available on ARM Cortex-M microcontrollers, not on ESP chips.
    ESP chips use different architectures:
    - ESP8266: Xtensa LX106
    - ESP32: Xtensa LX6
    - ESP32-C3: RISC-V
2025-12-29 Fix ESP32 build: add esp_err.h include for weak stub
2025-12-29 Add schematic SVG and LCSC verification tools
    - Add ESP32C3 XIAO schematic diagram in SVG format to README
    - Add analyze_components.py and verify_lcsc.py for LCSC part number validation
    - Updated scripts to use relative paths for portability
    - Updated KiCad schematic and PCB files with latest changes
    - Updated BOM and gerber files for manufacturing
2025-12-29 Fix ESP32-S3 linker error: remove weak attribute from vtarget_set_voltage stub
2025-12-30 Security hardening and USB/IP protocol compliance fixes
    - Security improvements:
    * Fixed buffer overflow vulnerabilities in wifi_handle.c by replacing strcpy with strncpy
    * Fixed duplicate NULL pointer check bug in DAP_handle.c (was checking dap_dataIN_handle twice)
    * Increased UART bridge stack size from 1024 to 2048 bytes to prevent stack overflow on ESP8266
    * Added security warnings for hardcoded WiFi credentials in wifi_configuration.h
    - USB/IP protocol compliance (v1.1.1 standard):
2025-12-30 Add batch script for flashing ESP32C3 device
    Added flash_eps.bat utility script for convenient firmware flashing to ESP32C3 via COM12 port using esptool at 460800 baud rate.
